# Keil uVision project BH-F103.uvprojx, settings and files
target as608 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: as608 +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\as608;..\..\User\led;..\..\User\SysTick;..\..\User\LD3320;..\..\User\Common;..\..\User\dwt_delay;..\..\User\ESP8266;..\..\User\Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/usart/: bsp_usart.c rx_data_queue.c bsp_usart1.c
    ../../User/as608/: as608_test.c bsp_as608.c
    ../../User/led/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/beep/: bsp_beep.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/font/: fonts.c
    ../../User/lcd/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c
    ../../User/Unlocking/: Unlocking.c
    ../../User/fingerprint/: fingerprint.c
    ../../User/Key_Board/: Key_Board.c
    ../../User/Change_password/: Change_password.c
    ../../User/interface/: interface.c
    ../../User/finger_ID/: finger_ID.c
    ../../User/LD3320/: LD3320.c
    ../../User/pwm/: pwm_config.c
    ../../User/Common/: Common.c
    ../../User/dwt_delay/: core_delay.c
    ../../User/ESP8266/: bsp_esp8266.c bsp_esp8266_test.c
  group DOC
    ../../Doc/: readme.txt
